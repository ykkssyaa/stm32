# Keil uVision project kurs.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: kurs
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: main.c lcd_ili93xx_driver.c lcd_ili93xx_driver.h
software components: CMSIS:CORE 5.5.0, Device:STM32Cube HAL:COMMON 1.11.3, Device:STM32Cube HAL:CORTEX 1.11.3, Device:STM32Cube HAL:DMA 1.11.3, Device:STM32Cube HAL:FLASH 1.11.3, Device:STM32Cube HAL:GPIO 1.11.3, Device:STM32Cube HAL:I2C 1.11.3, Device:STM32Cube HAL:RCC 1.11.3, Device:STM32Cube HAL:RTC 1.11.3, Device:STM32Cube HAL:SPI 1.11.3, Device:STM32Cube HAL:UART 1.11.3, Device:STM32Cube LL:COMMON 1.11.3, Device:STM32Cube LL:COMP 1.11.3, Device:STM32Cube LL:DMA 1.11.3, Device:STM32Cube LL:GPIO 1.11.3, Device:STM32Cube LL:I2C 1.11.3, Device:STM32Cube LL:PWR 1.11.3, Device:STM32Cube LL:RCC 1.11.3, Device:STM32Cube LL:USART 1.11.3, Device:STM32Cube LL:UTILS 1.11.3, Device:Startup 1.11.3
